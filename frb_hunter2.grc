options:
  parameters:
    generate_options: no_gui
    id: frb_hunter2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: awindow
  id: variable
  parameters:
    value: 2**(int(np.log2(crate/20))+1)
  states: {}
- name: buf_status
  id: variable
  parameters:
    value: frb_buf_mgr.save_frb_spectra(trigger_probe,cur_file,fftsize,longitude,prefix,decln,threshold,freq,samp_rate,crate)
  states: {}
- name: cur_file
  id: variable
  parameters:
    value: prefix + "frb-buffer-%d" % (int(time.time())  + (pacer_probe*0))
  states: {}
- name: harvest_pacer
  id: variable_function_probe
  parameters:
    block_id: anal_probe
    function_name: level
    poll_rate: 1.0/15.0
    value: '0'
  states: {}
- name: harvest_status
  id: variable
  parameters:
    value: frb_buf_mgr.harvest(harvest_pacer,prefix,permdir)
  states: {}
- name: pacer_probe
  id: variable_function_probe
  parameters:
    block_id: anal_probe
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: trigger_probe
  id: variable_function_probe
  parameters:
    block_id: anal_probe
    function_name: level
    poll_rate: '40'
    value: '0'
  states: {}
- name: anal_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: cur_file
    type: float
    unbuffered: 'True'
    vlen: fftsize
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: awindow
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/crate)
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: awindow
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/awindow
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: awindow
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: crate
  id: parameter
  parameters:
    label: Channel Rate
    type: intx
    value: '2500'
  states: {}
- name: decln
  id: parameter
  parameters:
    label: Declination
    type: eng_float
    value: '-99.0'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Input device
    type: str
    value: '"airspy,linearity=1"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '32'
  states: {}
- name: frb_buf_mgr
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport os\nimport ephem\nimport time\nimport numpy as np\nimport shutil\nimport glob\nimport copy\nimport shutil\nimport json\n\nrecently_triggered = 0\nevents = []\ndef cur_sidereal(longitude):\n    longstr = \"%02d\" % int(longitude)\n    longstr = longstr + \":\"\n    longitude = abs(longitude)\n    frac = longitude - int(longitude)\n    frac *= 60\n    mins = int(frac)\n    longstr += \"%02d\" % mins\n    longstr += \":00\"\n    x = ephem.Observer()\n    x.date = ephem.now()\n    x.long = longstr\n    jdate = ephem.julian_date(x)\n    tokens=str(x.sidereal_time()).split(\":\")\n    hours=int(tokens[0])\n    minutes=int(tokens[1])\n    seconds=int(float(tokens[2]))\n    sidt = \"%02d,%02d,%02d\" % (hours, minutes, seconds)\n    return (sidt)\n\ndef save_frb_spectra(trig_val, fn,fftsize,longitude,prefix,decln,thresh,freq,bw,crate):\n    global recently_triggered\n    global events\n    if (trig_val > thresh):\n        if (recently_triggered <= 0):\n            evt = time.time()\n            ltp = time.gmtime(evt)\n            frac = evt-float(int(evt))\n            events.append(int(evt))\n            newfn = \"frb-event-%d\" % (int(evt))\n            sidt = cur_sidereal(longitude)\n            sidbits = sidt.split(\",\")\n            newfn += \".json\"\n            evdict = {}\n            evdict[\"year\"] = ltp.tm_year\n            evdict[\"month\"] = ltp.tm_mon\n            evdict[\"day\"] = ltp.tm_mday\n            evdict[\"hour\"] = ltp.tm_hour\n            evdict[\"minute\"] = ltp.tm_min\n            evdict[\"second\"] = ltp.tm_sec\n            evdict[\"lmst_hour\"] = int(sidbits[0])\n            evdict[\"lmst_minute\"] = int(sidbits[1])\n            evdict[\"lmst_second\"] = int(sidbits[2])\n            evdict[\"frequency\"] = freq\n            evdict[\"bandwidth\"] = bw\n            evdict[\"chan_rate\"] = crate\n            evdict[\"declination\"] = decln\n            evdict[\"fftsize\"] = fftsize\n            evdict[\"threshold\"] = thresh\n            fp = open (prefix+newfn, \"w\")\n            fp.write(json.dumps(evdict, indent=4))\n            fp.write(\"\\n\")\n            fp.close()\n            \n            #\n            # Prevent re-triggering immediately\n            #\n            recently_triggered = 240\n        else:\n            recently_triggered -= 1\n        \n    return True\n\ndef harvest(pacer,prefix,permdir):\n    global events\n    flist = glob.glob(prefix+\"frb-buffer-*\")\n    myevents = copy.deepcopy(events)\n    \n    #\n    # Harvest data that isn't associated with an event\n    #\n    for f in flist:\n        ts = f.replace(prefix+\"frb-buffer-\", \"\")\n        ts = int(ts)\n        \n        #\n        # Time-indicator on file shows it is in the events list\n        #\n        if (ts in myevents or ts+1 in myevents or ts-1 in myevents):\n            continue\n        \n        #\n        # File cannot be removed unless it isn't in \"myevents\" AND it hasn't\n        #  been touched in 5 seconds or more\n        #\n        sts = os.stat(f)\n        if ((time.time() - sts.st_mtime) > 5):\n            os.remove(f)\n    #\n    # Anything that has survived the above gauntlet and is older than 10 seconds\n    #  likely deserves to be preserved as \"event data\"\n    #\n    for f in flist:\n        if (os.path.exists(f)):\n            sts = os.stat(f)\n            if ((time.time() - sts.st_mtime) > 10):\n                ts = f.replace(prefix+\"frb-buffer-\", \"\")\n                ts = int(ts)\n                \n                #\n                # Confirm in event data\n                #\n                if (ts in myevents or ts+1 in myevents or ts-1 in myevents):\n                    f2 = f.replace(\"buffer\", \"evdata\")\n                    f2 += \".bin\"\n                    shutil.move(f,permdir+os.path.basename(f2))\n                    f2 = f.replace(\"frb-buffer-\", \"frb-event-\")\n                    f2 += \".json\"\n                    if (os.path.exists(f2)):\n                        shutil.move(f2, permdir+os.path.basename(f2))\n                \n    return True\n    \n    \n    \n"
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Local Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    bw0: 0.8*samp_rate
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: permdir
  id: parameter
  parameters:
    label: File prefix for permanent event files
    type: str
    value: '"./"'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix for temporary event files
    type: str
    value: '"/run/user/%d" % (os.getuid()) + "/"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate/crate)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 10e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Trigger threshold
    type: eng_float
    value: '5.5'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_divide_xx_0, '0', anal_probe, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_integrate_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_file_sink_0, '0']
- [blocks_max_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']

metadata:
  file_format: 1
