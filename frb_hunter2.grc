options:
  parameters:
    generate_options: no_gui
    id: frb_hunter2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: crate
  id: variable
  parameters:
    comment: |-
      This gets computed.
      Basica strategy is to find
      the largest rate <= 4000
      that prdouces an integer
      decimation.
    value: frb_buf_mgr.compute_crate(fftsize,samp_rate,maxrate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: wr_status
  id: variable
  parameters:
    value: frb_buf_mgr.write_rate("frb_rate.txt", crate)
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna selector
    type: str
    value: '"RX2"'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '4096'
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: prefix+"frb_tmp.dat"
    type: float
    unbuffered: 'True'
    vlen: fftsize
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(seconds*samp_rate)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int((samp_rate/4096)/fftrate)
    type: complex
    vlen: '4096'
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '50'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: device
  id: parameter
  parameters:
    label: Input device
    type: str
    value: '"airspy,linearity=1"'
  states: {}
- name: fft_logger_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import math
      from gnuradio.fft import window
      import os
      import signal

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """FFT loggert"""

          def __init__(self, fftsize=4096, logfile="fft_log.out"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FFT Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.logfile = logfile
              self.lasttime = time.time()
              self.fftbuf = np.zeros(self.fftsize, dtype=np.float32)
              self.fftcnt = 0
              self.winpower = sum([x*x for x in window.blackmanharris(self.fftsize)])
              self.scale = 20*math.log10(self.fftsize) - 10*math.log10(self.winpower/self.fftsize)
              self.set_output_multiple(3)
              self.killctr = 0
              

          def work(self, input_items, output_items):
              """Log output of FFTT"""
              #
              # We keep the FFT power data in the linear domain until
              #  just before we log it.
              #
              #
              # Average-in all the input FFT buffers we've been handed
              #
              # We are called at an average rate of 10-20Hz, and with logging
              #   every two minutes, that's over 1000 samples in the averaging
              #   buffer.
              #
              now = time.time()
              for x in input_items[0]:
                  self.fftbuf = np.add(self.fftbuf, x)
                  self.fftcnt += 1
                  
              self.killctr += 1
              if (self.killctr >= 10):
                  if (os.path.exists("stop.txt")):
                      os.kill(os.getpid(), signal.SIGTERM)
                  self.killctr = 0
                  
              #
              # If time to log, compute the average, then convert to
              #    10Log10 and apply scaling
              #
              if ((now - self.lasttime) > 120):
                  self.lasttime = now
                  fp = open(self.logfile, "w")
                  
                  #
                  # Provides protection against (unlikely)
                  #  self.fftbuf being 0 after all those adds.
                  #
                  self.fftbuf = np.add(self.fftbuf, 1.0e-14)
                  
                  
                  #
                  # Compute (linear) average
                  #
                  self.fftbuf = np.divide(self.fftbuf,self.fftcnt)
                  
                  #
                  # Convert to 10log10
                  #
                  self.fftbuf = np.log10(self.fftbuf)
                  self.fftbuf = np.multiply(self.fftbuf,10.0)
                  
                  #
                  # Subtract-out the scale factor
                  #
                  self.fftbuf = np.subtract(self.fftbuf, self.scale)
                  
                  for i in range(0,self.fftsize):
                      fp.write("%.3f" % self.fftbuf[i])
                      if (i < self.fftsize-1):
                          fp.write(",")
                  fp.write("\n")
                  self.fftcnt = 0
                  self.fftbuf = np.zeros(self.fftsize,dtype=np.float32)
                  fp.close()
                  
                  
                  
              return len(input_items[0])
    fftsize: '4096'
    logfile: prefix+logfile
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(4096)
  states: {}
- name: fftrate
  id: parameter
  parameters:
    label: Rate of monitor FFT
    type: intx
    value: '15'
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '32'
  states: {}
- name: frb_buf_mgr
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport os\nimport ephem\nimport time\nimport numpy as np\nimport shutil\nimport glob\nimport copy\nimport shutil\nimport json\nimport math\n\nmovelist = []\n\ndef getalpha(corner, srate):\n\tq = math.pow(math.e,-2.0*(corner/srate))\n\talpha = 1.0 - q\n\treturn alpha\n\n\ndef write_rate(fn, rate):\n    fp = open(fn, \"w\")\n    fp.write(\"%d\\n\" % rate)\n    fp.close()\n    return True\n\n\ndef compute_crate(fftsize,srate,maxrate):\n    rates = [x for x in range(maxrate,2500,-5)]\n    for r in rates:\n        d = float(srate)/float(fftsize)\n        d /= float(r)\n        \n        if (d == float(int(d))):\n            return r\n    return 2500\n\n    \n"
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: logfile
  id: parameter
  parameters:
    label: Logfile name
    type: str
    value: '"fft_log.out"'
  states: {}
- name: maxrate
  id: parameter
  parameters:
    label: Maximum output sample rate
    type: intx
    value: int(4e3)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: antenna
    args: device
    bb_gain0: '20'
    bw0: 0.8*samp_rate
    clock_source0: refsource
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: timesource
    type: fc32
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix for temporary event files
    type: str
    value: '"/run/user/%d" % (os.getuid()) + "/"'
  states: {}
- name: refsource
  id: parameter
  parameters:
    label: Reference SOurce
    type: str
    value: '"internal"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: rx_time_catcher
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Catch the first rx_timestamp"""

          def __init__(self, rxfile="rxfile.txt",fftsize=32,crate=2500,srate=25e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='rx_time catcher',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.rxfile = rxfile
              self.first = True
              
              #
              # FFT outputs occur at srate/fftsize
              #
              self.fftrate = srate/fftsize
              
              #
              # This is then decimated at "self.decim" to produce the actual outputs
              #
              self.decim = self.fftrate / crate
              
              #
              # Which means the first output sample is produced at a time that is
              #  offset from the first input sample
              #
              self.offset = (1.0/self.fftrate) * self.decim

          def work(self, input_items, output_items):
              if (self.first == True):
                  # Get rx_time tag
                  self.first = False
                  tags = self.get_tags_in_window(0, 0, len(input_items[0]))
                  for tag in tags:
                      key = pmt.to_python(tag.key) # convert from PMT to python string
                      value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                      if (key == "rx_time"):
                          break
                  fp = open(self.rxfile, "w")
                  #fp.write("%s" % str(value))
                  timestump = float(value[0])+float(value[1])
                  timestump += self.offset
                  fp.write("%13.7f\n" % timestump)
                  fp.close()
              return len(input_items[0])
    crate: crate
    fftsize: '32'
    rxfile: prefix+"rxfile.txt"
    srate: samp_rate
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Runtime seconds
    type: intx
    value: '600'
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: frb_buf_mgr.getalpha(crate,(samp_rate/fftsize))
    type: float
    vlen: fftsize
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 25e6
  states: {}
- name: time_catcher
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import math
      from gnuradio.fft import window
      import os
      import signal

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Time Catcher"""

          def __init__(self, fftsize=32,tsfile="tsfile.txt"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Time Catcher',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.tsfile = tsfile
              self.first = True
              

          def work(self, input_items, output_items):
              """Capture timestamp on first record"""
              if (self.first == True):
                  fp = open(self.tsfile, "w")
                  fp.write("%13.6f\n" % time.time())
                  fp.close()
                  self.first = False
              return len(input_items[0])
    fftsize: fftsize
    tsfile: prefix+'tsfile.txt'
  states: {}
- name: timesource
  id: parameter
  parameters:
    label: PPS Source
    type: str
    value: '"internal"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: integ_fft
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: integ_fft
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', fft_logger_1, '0']
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_1, '0']
- [blocks_keep_one_in_n_1, '0', virtual_sink_0, '0']
- [blocks_keep_one_in_n_2, '0', rx_time_catcher, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']
- [osmosdr_source_0, '0', blocks_keep_one_in_n_2, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']
- [virtual_source_0_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0_0, '0', time_catcher, '0']

metadata:
  file_format: 1
