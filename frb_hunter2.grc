options:
  parameters:
    generate_options: no_gui
    id: frb_hunter2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: awindow
  id: variable
  parameters:
    value: 2**(int(np.log2(crate/10))+1)
  states: {}
- name: crate
  id: variable
  parameters:
    comment: |-
      This gets computed.
      Basica strategy is to find
      the largest rate <= 4000
      that prdouces an integer
      decimation.
    value: frb_buf_mgr.compute_crate(fftsize,samp_rate)
  states: {}
- name: cur_file
  id: variable
  parameters:
    value: prefix + "frb-buffer-%d" % (int(ts))
  states: {}
- name: fileseconds
  id: variable
  parameters:
    value: '10'
  states: {}
- name: harvest_pacer
  id: variable_function_probe
  parameters:
    block_id: anal_probe
    function_name: level
    poll_rate: 1.0/30.0
    value: '0'
  states: {}
- name: harvest_status
  id: variable
  parameters:
    value: frb_buf_mgr.harvest(harvest_pacer,prefix,permdir,fileseconds)
  states: {}
- name: pacer_probe
  id: variable_function_probe
  parameters:
    block_id: anal_probe
    function_name: level
    poll_rate: 1/fileseconds
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: ts
  id: variable
  parameters:
    value: time.time() + (0 * pacer_probe)
  states: {}
- name: anal_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: |-
      This will produce a ratio between the long-term
      average, and the "spikier" realtime signal.
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: cur_file
    type: float
    unbuffered: 'True'
    vlen: fftsize
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: fftsize
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      We arrange to only look at the middle 10% of
      the bandwidth, to reduce smearing effects.

      This *should* work for very bright FRBs.
    const: frb_buf_mgr.tp_vector(fftsize)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: float
  states: {}
- name: decln
  id: parameter
  parameters:
    label: Declination
    type: str
    value: '-99.0'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Input device
    type: str
    value: '"airspy,linearity=1"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '32'
  states: {}
- name: frb_analyser1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import ephem
      import time
      import json
      import os



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, crate=2500, threshold=10.0, prefix="./", longitude=-76.03, decln=-99.0,fftsize=32,freq=1420.405e6,srate=10e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FRB analyser block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.crate = crate
              self.threshold = threshold
              self.prefix = prefix
              self.holdoff = self.crate*2
              self.longitude = longitude
              self.decln = decln
              self.fftsize = fftsize
              self.freq = freq
              self.srate = srate
              
          def cur_sidereal(self,longitude):
              longstr = "%02d" % int(longitude)
              longstr = longstr + ":"
              longitude = abs(longitude)
              frac = longitude - int(longitude)
              frac *= 60
              mins = int(frac)
              longstr += "%02d" % mins
              longstr += ":00"
              x = ephem.Observer()
              x.date = ephem.now()
              x.long = longstr
              jdate = ephem.julian_date(x)
              tokens=str(x.sidereal_time()).split(":")
              hours=int(tokens[0])
              minutes=int(tokens[1])
              seconds=int(float(tokens[2]))
              sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
              return (sidt)
          
          def record_event(self,prefix,longit,decln,fftsize,freq,srate,crate,thresh,offs):
              evt = time.time()
              evt -= offs
              ltp = time.gmtime(evt)
              frac = evt-float(int(evt))
              
              if (os.path.exists(decln)):
                  fp = open(decln, "r")
                  x = fp.readline()
                  decln = float(x)
                  fp.close()
              else:
                  decln = float(decln)

              newfn = "frb-event-%d" % (int(evt))
              sidt = self.cur_sidereal(longit)
              sidbits = sidt.split(",")
              newfn += ".json"
              evdict = {}
              evdict["year"] = ltp.tm_year
              evdict["month"] = ltp.tm_mon
              evdict["day"] = ltp.tm_mday
              evdict["hour"] = ltp.tm_hour
              evdict["minute"] = ltp.tm_min
              evdict["second"] = "%.2f" % (float(ltp.tm_sec)+frac)
              evdict["lmst_hour"] = int(sidbits[0])
              evdict["lmst_minute"] = int(sidbits[1])
              evdict["lmst_second"] = int(sidbits[2])
              evdict["frequency"] = freq
              evdict["bandwidth"] = srate
              evdict["chan_rate"] = crate
              evdict["declination"] = decln
              evdict["fftsize"] = fftsize
              evdict["threshold"] = thresh
              fp = open (prefix+newfn, "w")
              fp.write(json.dumps(evdict, indent=4))
              fp.write("\n")
              fp.close()
              return True

          def work(self, input_items, output_items):
              """Do something when signal exceeds threshold"""
              
              #
              # If still in hold-off, do nothing, decrement hold-off counter
              #
              if (self.holdoff > 0):
                  l = len(input_items[0])
                  self.holdoff -= l
                  return l
              
              #
              # Find the largest item, which is a *ratio* between the instantaneous signal
              #   and the longer-term average
              #
              mx = np.max(input_items[0])
              
              #
              # If the highest value in the input buffer exceeds threshold AND
              #   it isn't "too large", then declare an event.
              #
              # If it's "too large", it VERY likely isn't of astronomical origin.
              #
              if mx > self.threshold and mx < 100.0:
                  self.holdoff = self.crate * 2
                  
                  #
                  # Compute offset time of event
                  #
                  offs = np.argmax(input_items[0])
                  offs = len(input_items[0]) - offs
                  offs *= (1.0/float(self.crate))
                  
                  self.record_event(self.prefix,self.longitude,self.decln,
                      self.fftsize,self.freq,self.srate,self.crate,self.threshold,offs)
              
              return len(input_items[0])
    crate: crate
    decln: decln
    fftsize: fftsize
    freq: freq
    longitude: longitude
    prefix: prefix
    srate: samp_rate
    threshold: threshold
  states: {}
- name: frb_buf_mgr
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport os\nimport ephem\nimport time\nimport numpy as np\nimport shutil\nimport glob\nimport copy\nimport shutil\nimport json\n\nmovelist = []\n\n#\n# Helper to produce a vector that is mostly zeros, but with 1s in the middle 10%\n#\ndef tp_vector(fftsize):\n    rvec = [0.0]*fftsize\n    mid = int(fftsize/2)\n    tenp = float(fftsize)*0.1\n    tenp = int(tenp)\n    fivep = int(tenp/2)\n    for ndx in range(mid-fivep,mid+fivep+1):\n        rvec[ndx] = 1.0\n    return rvec\n\ndef harvest(pacer,prefix,permdir,seconds):\n    global movelist\n    \n    #\n    # Handle files on the \"movelist\"\n    #\n    for f in movelist:\n        shutil.move(f,permdir)\n    \n    movelist = []\n    \n    #\n    # Harvest data that isn't associated with an event\n    #\n    \n    #\n    # First find \"event\" files in the buffer directory\n    #\n    flist = glob.glob(prefix+\"frb-event-*\")\n    \n    #\n    # Create empty event dictionary\n    #\n    evdict = {}\n    for f in flist:\n        sts = os.stat(f)\n        #\n        # Add event only if it's \"fresh\"\n        #\n        if ((time.time() - sts.st_mtime) <= seconds*10):\n            evdict[f] = sts.st_mtime\n        \n        #\n        # Otherwise, remove\n        #\n        else:\n            os.remove(f)\n            \n    #\n    # Find matching buffer file\n    #\n    flist = glob.glob(prefix+\"frb-buffer-*\")\n    for f in flist:\n        sts = os.stat(f)\n        \n        #\n        # We have a buffer file, see if there's a matching \"event\" file\n        #\n        for ev in evdict:\n            #\n            # If the event falls within the purview of the buffer file\n            #\n            if sts.st_mtime > evdict[ev] and (sts.st_mtime-seconds) < evdict[ev]:\n                #\n                # Move event file to perm directory\n                #\n                try:\n                    shutil.move(ev,permdir)\n                except:\n                    pass\n                \n                if ((time.time() - sts.st_mtime) > seconds):\n                    try:\n                        shutil.move(f,permdir)\n                    except:\n                        pass\n                else:\n                    #\n                    # Defer buffer movement to next cycle--buffer may be partially-full\n                    #\n                    movelist.append(f)\n                \n    \n    #\n    # Delete buffers that are old enough and didn't match any events\n    #\n    for f in flist:\n        if (f not in movelist):\n            if os.path.exists(f):\n                sts = os.stat(f)\n                if ((time.time() - sts.st_mtime) > seconds*10):\n                    os.remove(f)        \n        \n    return True\n    \n\ndef compute_crate(fftsize,srate):\n    rates = [x for x in range(4200,2500,-25)]\n    \n    for r in rates:\n        d = float(srate)/float(fftsize)\n        d /= float(r)\n        \n        if (d == float(int(d))):\n            return r\n    return 2500\n\n    \n"
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Local Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      FFT output is a vector
      total power is the sum of each element
      of the vector.
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    bw0: 0.8*samp_rate
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: permdir
  id: parameter
  parameters:
    label: File prefix for permanent event files
    type: str
    value: '"./"'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix for temporary event files
    type: str
    value: '"/run/user/%d" % (os.getuid()) + "/"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: single_pole_iir_filter_xx_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(crate*5.0)
    comment: Longer-term average to establish baseline
    type: float
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 10e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Trigger threshold
    type: eng_float
    value: '5.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: integ_fft
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: integ_fft
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: integ_fft
  states: {}

connections:
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_divide_xx_0, '0', anal_probe, '0']
- [blocks_divide_xx_0, '0', frb_analyser1, '0']
- [blocks_integrate_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_integrate_xx_0, '0', single_pole_iir_filter_xx_2, '0']
- [blocks_keep_one_in_n_1, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']
- [single_pole_iir_filter_xx_2, '0', blocks_divide_xx_0, '1']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
