options:
  parameters:
    generate_options: no_gui
    id: frb_hunter2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: awindow
  id: variable
  parameters:
    value: 2**(int(np.log2(crate/10))+1)
  states: {}
- name: crate
  id: variable
  parameters:
    comment: |-
      This gets computed.
      Basica strategy is to find
      the largest rate <= 4000
      that prdouces an integer
      decimation.
    value: frb_buf_mgr.compute_crate(fftsize,samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: wr_status
  id: variable
  parameters:
    value: frb_buf_mgr.write_rate("frb_rate.txt", crate)
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: prefix+"frb_tmp.dat"
    type: float
    unbuffered: 'True'
    vlen: fftsize
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(seconds*samp_rate)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: decln
  id: parameter
  parameters:
    label: Declination
    type: str
    value: '-99.0'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Input device
    type: str
    value: '"airspy,linearity=1"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '16'
  states: {}
- name: frb_buf_mgr
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport os\nimport ephem\nimport time\nimport numpy as np\nimport shutil\nimport glob\nimport copy\nimport shutil\nimport json\n\nmovelist = []\n\n#\n# Helper to produce a vector that is mostly zeros, but with 1s in the middle 10%\n#\ndef tp_vector(fftsize):\n    rvec = [0.0]*fftsize\n    mid = int(fftsize/2)\n    tenp = float(fftsize)*0.1\n    tenp = int(tenp)\n    fivep = int(tenp/2)\n    for ndx in range(mid-fivep,mid+fivep+1):\n        rvec[ndx] = 1.0\n    return rvec\n\ndef harvest(pacer,prefix,permdir,seconds):\n    global movelist\n    \n    #\n    # Handle files on the \"movelist\"\n    #\n    for f in movelist:\n        shutil.move(f,permdir)\n    \n    movelist = []\n    \n    #\n    # Harvest data that isn't associated with an event\n    #\n    \n    #\n    # First find \"event\" files in the buffer directory\n    #\n    flist = glob.glob(prefix+\"frb-event-*\")\n    \n    #\n    # Create empty event dictionary\n    #\n    evdict = {}\n    for f in flist:\n        sts = os.stat(f)\n        #\n        # Add event only if it's \"fresh\"\n        #\n        if ((time.time() - sts.st_mtime) <= seconds*10):\n            evdict[f] = sts.st_mtime\n        \n        #\n        # Otherwise, remove\n        #\n        else:\n            os.remove(f)\n            \n    #\n    # Find matching buffer file\n    #\n    flist = glob.glob(prefix+\"frb-buffer-*\")\n    for f in flist:\n        sts = os.stat(f)\n        \n        #\n        # We have a buffer file, see if there's a matching \"event\" file\n        #\n        for ev in evdict:\n            #\n            # If the event falls within the purview of the buffer file\n            #\n            if sts.st_mtime > evdict[ev] and (sts.st_mtime-seconds) < evdict[ev]:\n                #\n                # Move event file to perm directory\n                #\n                try:\n                    shutil.move(ev,permdir)\n                except:\n                    pass\n                \n                if ((time.time() - sts.st_mtime) > seconds):\n                    try:\n                        shutil.move(f,permdir)\n                    except:\n                        pass\n                else:\n                    #\n                    # Defer buffer movement to next cycle--buffer may be partially-full\n                    #\n                    movelist.append(f)\n                \n    \n    #\n    # Delete buffers that are old enough and didn't match any events\n    #\n    for f in flist:\n        if (f not in movelist):\n            if os.path.exists(f):\n                sts = os.stat(f)\n                if ((time.time() - sts.st_mtime) > seconds*10):\n                    os.remove(f)        \n        \n    return True\n\ndef write_rate(fn, rate):\n    fp = open(fn, \"w\")\n    fp.write(\"%d\\n\" % rate)\n    fp.close()\n    return True\n\n\ndef compute_crate(fftsize,srate):\n    rates = [x for x in range(6500,2500,-25)]\n    \n    for r in rates:\n        d = float(srate)/float(fftsize)\n        d /= float(r)\n        \n        if (d == float(int(d))):\n            return r\n    return 2500\n\n    \n"
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Local Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    bw0: 0.8*samp_rate
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: permdir
  id: parameter
  parameters:
    label: File prefix for permanent event files
    type: str
    value: '"./"'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix for temporary event files
    type: str
    value: '"/run/user/%d" % (os.getuid()) + "/"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Runtime seconds
    type: intx
    value: '600'
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate/fftsize/crate)
    type: float
    vlen: fftsize
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 10e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Trigger threshold
    type: eng_float
    value: '5.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: integ_fft
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: integ_fft
  states: {}

connections:
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_keep_one_in_n_1, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']
- [virtual_source_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
