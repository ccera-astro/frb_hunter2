options:
  parameters:
    generate_options: no_gui
    id: frb_bulk_analyser
    output_language: python
    run_options: run
    title: FRB Bulk ANalyser
  states: {}

blocks:
- name: dinc
  id: variable
  parameters:
    value: int(sdelay/16)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: fftsize
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: dinc*0
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: dinc*1
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: dinc*9
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: dinc*2
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: dinc*10
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: dinc*3
    type: float
  states: {}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: dinc*11
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: dinc*4
    type: float
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: dinc*5
    type: float
  states: {}
- name: blocks_delay_0_3_0_0
  id: blocks_delay
  parameters:
    delay: dinc*13
    type: float
  states: {}
- name: blocks_delay_0_3_1
  id: blocks_delay
  parameters:
    delay: dinc*12
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: dinc*6
    type: float
  states: {}
- name: blocks_delay_0_4_0
  id: blocks_delay
  parameters:
    delay: dinc*14
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: dinc*7
    type: float
  states: {}
- name: blocks_delay_0_5_0
  id: blocks_delay
  parameters:
    delay: dinc*15
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: dinc*8
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: infile
    repeat: 'False'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: fftsize
    type: float
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '16'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: infile
  id: parameter
  parameters:
    label: Input File
    type: str
    value: '"/dev/null"'
  states: {}
- name: pulse_finder_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """FRB Pulse finder - a simple multiply const"""

          def __init__(self, threshold=4.0, srate=6250, tstamp=time.time(), seconds=10*60):  # only default arguments here
              """Args:
                   threshold - detection threshold as a ratio
                   srate - original effective sample rate going into detetor
                   tstamp - timestamp of input file"""
              gr.sync_block.__init__(
                  self,
                  name='FRB Pulse Finder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.srate = srate
              self.tstamp = tstamp
              self.scount = 0
              self.seconds = seconds
              self.holdoff = self.srate * 30

          def work(self, input_items, output_items):
              """Look for samples with larger SNR"""
              l = len(input_items[0])
              if (self.holdoff > 0):
                  self.holdoff -= l
                  self.scount += l
                  return l
              mx = np.max(input_items[0])
              if (mx > self.threshold and mx < 50.0):
                  start = self.tstamp - self.seconds
                  mxa = np.argmax(input_items[0])
                  evt = start + float(self.scount)/float(self.srate)
                  evt += float(mxa) / float(self.srate)
                  fp = open ("frb-event.dat", "w")
                  ltp = time.gmtime(evt)
                  frac = evt - float(int(evt))
                  fp.write("%04d%02d%02d-%02d%02d%05.2f %.2f\n" % (ltp.tm_year, ltp.tm_mon,
                      ltp.tm_mday, ltp.tm_hour, ltp.tm_min, float(ltp.tm_sec)+frac, frac, mx))
                  fp.close()
                  self.holdoff = self.srate * 10
              self.scount += l
              return len(input_items[0])
    seconds: seconds
    srate: samp_rate
    threshold: '5.0'
    tstamp: os.stat(infile).st_mtime
  states: {}
- name: sdelay
  id: parameter
  parameters:
    label: Max dispersion delay, in samples
    type: intx
    value: '16'
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: How many seconds of data in input
    type: intx
    value: 10*60
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate*5)
    type: float
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Data sample rate
    type: intx
    value: '6250'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '9']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0, '10']
- [blocks_delay_0_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_2_0, '0', blocks_add_xx_0, '11']
- [blocks_delay_0_3, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_3_0, '0', blocks_add_xx_0, '5']
- [blocks_delay_0_3_0_0, '0', blocks_add_xx_0, '13']
- [blocks_delay_0_3_1, '0', blocks_add_xx_0, '12']
- [blocks_delay_0_4, '0', blocks_add_xx_0, '6']
- [blocks_delay_0_4_0, '0', blocks_add_xx_0, '14']
- [blocks_delay_0_5, '0', blocks_add_xx_0, '7']
- [blocks_delay_0_5_0, '0', blocks_add_xx_0, '15']
- [blocks_delay_0_6, '0', blocks_add_xx_0, '8']
- [blocks_divide_xx_0, '0', pulse_finder_1, '0']
- [blocks_file_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_delay_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_delay_0_0, '0']
- [blocks_vector_to_streams_0, '10', blocks_delay_0_1_0, '0']
- [blocks_vector_to_streams_0, '11', blocks_delay_0_2_0, '0']
- [blocks_vector_to_streams_0, '12', blocks_delay_0_3_1, '0']
- [blocks_vector_to_streams_0, '13', blocks_delay_0_3_0_0, '0']
- [blocks_vector_to_streams_0, '14', blocks_delay_0_4_0, '0']
- [blocks_vector_to_streams_0, '15', blocks_delay_0_5_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_delay_0_1, '0']
- [blocks_vector_to_streams_0, '3', blocks_delay_0_2, '0']
- [blocks_vector_to_streams_0, '4', blocks_delay_0_3, '0']
- [blocks_vector_to_streams_0, '5', blocks_delay_0_3_0, '0']
- [blocks_vector_to_streams_0, '6', blocks_delay_0_4, '0']
- [blocks_vector_to_streams_0, '7', blocks_delay_0_5, '0']
- [blocks_vector_to_streams_0, '8', blocks_delay_0_6, '0']
- [blocks_vector_to_streams_0, '9', blocks_delay_0_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_divide_xx_0, '1']

metadata:
  file_format: 1
