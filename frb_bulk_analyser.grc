options:
  parameters:
    generate_options: no_gui
    id: frb_bulk_analyser
    output_language: python
    run_options: run
    title: FRB Bulk ANalyser
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: fftsize
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*0)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*1)
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*9)
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: int(sdelay*2)
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*10)
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: int(sdelay*3)
    type: float
  states: {}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*11)
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: int(sdelay*4)
    type: float
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*5)
    type: float
  states: {}
- name: blocks_delay_0_3_0_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*13)
    type: float
  states: {}
- name: blocks_delay_0_3_1
  id: blocks_delay
  parameters:
    delay: int(sdelay*12)
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: int(sdelay*6)
    type: float
  states: {}
- name: blocks_delay_0_4_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*14)
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: int(sdelay*7)
    type: float
  states: {}
- name: blocks_delay_0_5_0
  id: blocks_delay
  parameters:
    delay: int(sdelay*15)
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: int(sdelay*8)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: prefix+"frb_dedisp.dat"
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: infile
    repeat: 'False'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: fftsize
    type: float
  states: {}
- name: declination
  id: parameter
  parameters:
    label: Declination
    type: eng_float
    value: '-99.0'
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '16'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: infile
  id: parameter
  parameters:
    label: Input File
    type: str
    value: '"/dev/null"'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Local longitude
    type: eng_float
    value: '-76.108'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix
    type: str
    value: '"./"'
  states: {}
- name: pulse_finder_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport ephem\nimport json\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"FRB Pulse finder - a simple multiply const\"\"\"\n\n    def __init__(self, threshold=4.0, srate=6250, tstamp=time.time(), seconds=10*60, longitude=-76.108, declination=-99.0, prefix=\"./\", sdelay=0.0, ra=-1.0):  # only default arguments here\n        \"\"\"Args:\n             threshold - detection threshold as a ratio\n             srate - original effective sample rate going into detetor\n             tstamp - timestamp of input file\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='FRB Pulse Finder',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.threshold = threshold\n        self.srate = srate\n        self.tstamp = tstamp\n        self.scount = 0\n        self.seconds = seconds\n        self.holdoff = self.srate * 30\n        self.longitude = longitude\n        self.declination = declination\n        self.prefix = prefix\n        self.workcount = 0\n        self.set_output_multiple(int(self.srate))\n        self.sdelay = sdelay\n        self.ra = ra\n\n    def work(self, input_items, output_items):\n        \"\"\"Look for samples with larger SNR\"\"\"\n        l = len(input_items[0])\n\n        offset = 0\n        \n        \n        #\n        # Deal with hold-off\n        #\n        # We have a hold-off just to avoid declaring an event during\n        #  the first little bit of the filterbank file, which would include\n        #  start-up transients from the hardware\n        #\n        \n        #\n        # Stil have some hold-off remaining?\n        #\n        if (self.holdoff > 0):\n            \n            #\n            # More hold-off than input buffer?\n            #\n            if (self.holdoff >= l):\n                self.holdoff -= l\n                self.scount += l\n                return l\n            \n            #\n            # Input buffer longer than hold-off\n            #   zero hold-off, and compute offset\n            #\n            else:\n                offset = self.holdoff\n                self.holdoff = 0\n        \n        #\n        # Get largest item in input buffer\n        #\n        # Compute mean and standard deviation\n        #\n        mx = np.max(input_items[0][offset:])\n        std = np.std(input_items[0][offset:])\n        mean = np.mean(input_items[0][offset:])\n\n        \n        #\n        # Is it larger than threshold but smaller than horrendous?\n        #\n        #\n        sigma = (mx-mean)/std\n        if (sigma > self.threshold and sigma < 50.0):\n            \n            #\n            # Determine what the notional start-time of the\n            #  input filterbank file is.\n            #\n            start = self.tstamp - self.seconds\n            \n            #\n            # Determine offset of max from start of input buffer\n            #\n            mxa = np.argmax(input_items[0][offset:])\n            mxa += offset\n            \n            #\n            # Event time is start + the current sample-count/rate,\n            #   plus the buffer offset where the event occcured.\n            #\n            evt = start + float(self.scount)/float(self.srate)\n            evt += float(mxa) / float(self.srate)\n            \n           \n            \n            #\n            # Create a dictionary that will get written out as JSON\n            #\n            evdict = {}\n            evdict[\"declination\"] = self.declination\n            ltp = time.gmtime(evt)\n            frac = evt - float(int(evt))\n            evdict[\"date\"] = \"%04d %02d %02d\" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)\n            evdict[\"evtime\"] = \"%02d:%02d:%05.2f\" % (ltp.tm_hour, ltp.tm_min,\n                float(ltp.tm_sec)+frac)\n            evdict[\"max\"] = float(mx)\n            evdict[\"sigma\"] = float(sigma)\n            evdict[\"lmst\"] = self.cur_sidereal(self.longitude,evt)\n            curd = evdict[\"lmst\"].split(\",\")\n            curd = float(curd[0])+(float(curd[1])/60.0)\n            evdict[\"srate\"] = int(self.srate)\n            evdict[\"scount\"] = int(self.scount+mxa)\n            evdict[\"sdelay\"] = self.sdelay\n            evdict[\"maxdelay\"] = self.sdelay * 16.0 * (1.0/ self.srate)\n            wevent = False\n            if (self.ra >= 0.0):\n                if ((abs(self.ra) - self.curd) < 0.3):\n                    wevent = True\n            else:\n                wevent = True\n                \n            if (wevent == True):\n                #\n                # Open an \"event\" json file\n                #\n                fp = open (self.prefix+\"frb-event.json\", \"w\")\n                fp.write(json.dumps(evdict,indent=4))\n                fp.close()\n        self.scount += l\n        return l\n    \n    # Given longitude(decimal degrees as a float)\n    #\n    # Return the current sidereal time as a string with\n    #  \",\" separated tokens\n    #\n    def cur_sidereal(self,longitude,utime):\n        longstr = \"%02d\" % int(longitude)\n        longstr = longstr + \":\"\n        longitude = abs(longitude)\n        frac = longitude - int(longitude)\n        frac *= 60\n        mins = int(frac)\n        longstr += \"%02d\" % mins\n        longstr += \":00\"\n        x = ephem.Observer()\n        ltp = time.gmtime(utime)\n        tmstr = \"%04d/%02d/%02d %02d:%02d:%02d\" % (ltp.tm_year,\n            ltp.tm_mon, ltp.tm_mday, ltp.tm_hour, ltp.tm_min, ltp.tm_sec)\n        x.date = ephem.Date(tmstr)\n        x.long = longstr\n        jdate = ephem.julian_date(x)\n        tokens=str(x.sidereal_time()).split(\":\")\n        hours=int(tokens[0])\n        minutes=int(tokens[1])\n        seconds=int(float(tokens[2]))\n        sidt = \"%02d,%02d,%02d\" % (hours, minutes, seconds)\n        return (sidt)\n\n        \n"
    declination: declination
    longitude: longitude
    prefix: prefix
    ra: '-1.0'
    sdelay: sdelay
    seconds: seconds
    srate: samp_rate
    threshold: threshold
    tstamp: os.stat(infile).st_mtime
  states: {}
- name: ra
  id: parameter
  parameters:
    label: Special Attenton RA
    type: eng_float
    value: '-1.0'
  states: {}
- name: sdelay
  id: parameter
  parameters:
    label: Dispersion delay increment
    type: eng_float
    value: '0.75'
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: How many seconds of data in input
    type: intx
    value: 10*60
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Data sample rate
    type: intx
    value: '6250'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Detection threshold
    type: eng_float
    value: '5.5'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_xx_0, '0', pulse_finder_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '9']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0, '10']
- [blocks_delay_0_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_2_0, '0', blocks_add_xx_0, '11']
- [blocks_delay_0_3, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_3_0, '0', blocks_add_xx_0, '5']
- [blocks_delay_0_3_0_0, '0', blocks_add_xx_0, '13']
- [blocks_delay_0_3_1, '0', blocks_add_xx_0, '12']
- [blocks_delay_0_4, '0', blocks_add_xx_0, '6']
- [blocks_delay_0_4_0, '0', blocks_add_xx_0, '14']
- [blocks_delay_0_5, '0', blocks_add_xx_0, '7']
- [blocks_delay_0_5_0, '0', blocks_add_xx_0, '15']
- [blocks_delay_0_6, '0', blocks_add_xx_0, '8']
- [blocks_file_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_delay_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_delay_0_0, '0']
- [blocks_vector_to_streams_0, '10', blocks_delay_0_1_0, '0']
- [blocks_vector_to_streams_0, '11', blocks_delay_0_2_0, '0']
- [blocks_vector_to_streams_0, '12', blocks_delay_0_3_1, '0']
- [blocks_vector_to_streams_0, '13', blocks_delay_0_3_0_0, '0']
- [blocks_vector_to_streams_0, '14', blocks_delay_0_4_0, '0']
- [blocks_vector_to_streams_0, '15', blocks_delay_0_5_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_delay_0_1, '0']
- [blocks_vector_to_streams_0, '3', blocks_delay_0_2, '0']
- [blocks_vector_to_streams_0, '4', blocks_delay_0_3, '0']
- [blocks_vector_to_streams_0, '5', blocks_delay_0_3_0, '0']
- [blocks_vector_to_streams_0, '6', blocks_delay_0_4, '0']
- [blocks_vector_to_streams_0, '7', blocks_delay_0_5, '0']
- [blocks_vector_to_streams_0, '8', blocks_delay_0_6, '0']
- [blocks_vector_to_streams_0, '9', blocks_delay_0_0_0, '0']

metadata:
  file_format: 1
