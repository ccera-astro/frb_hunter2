options:
  parameters:
    generate_options: no_gui
    id: channel_extract
    output_language: python
    run_options: run
    title: FB Channel extractor and delay
  states: {}

blocks:
- name: chanpref
  id: variable
  parameters:
    value: '[0]*(channel)+[1.0]'
  states: {}
- name: chanvector
  id: variable
  parameters:
    value: chanpref+[0]*(fbsize-len(chanpref))
  states: {}
- name: lchannel
  id: variable
  parameters:
    value: len(chanvector)
  states: {}
- name: lchanpref
  id: variable
  parameters:
    value: len(chanpref)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: addfile
  id: parameter
  parameters:
    label: Adding file
    type: str
    value: '"/dev/zero"'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: outfile
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: infile
    repeat: 'False'
    type: float
    vlen: fbsize
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: addfile
    repeat: 'False'
    type: float
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: fbsize
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: chanvector
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fbsize
    type: float
  states: {}
- name: channel
  id: parameter
  parameters:
    label: Channel number of interest
    type: intx
    value: '31'
  states: {}
- name: delay
  id: parameter
  parameters:
    label: Delay in samples for the channel
    type: intx
    value: '0'
  states: {}
- name: fbsize
  id: parameter
  parameters:
    label: Filterbank size
    type: intx
    value: '32'
  states: {}
- name: infile
  id: parameter
  parameters:
    label: Output filename
    type: str
    value: '"extracted.dat"'
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output filename
    type: str
    value: '"extracted.dat"'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '3125'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_1, '0', blocks_add_xx_0, '1']
- [blocks_integrate_xx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_0, '0']

metadata:
  file_format: 1
